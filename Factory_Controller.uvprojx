# Keil uVision project Factory_Controller.uvprojx, settings and files
target Factory_Controller (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Factory_Controller
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: D:\ti\TivaWare_C_Series-2.1.3.156\;D:\ti\TivaWare_C_Series-2.1.3.156\driverlib;D:\ti\TivaWare_C_Series-2.1.3.156\driverlib\rvmdk;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS;D:\ti\TivaWare_C_Series-2.1.3.156\usblib;D:\ti\TivaWare_C_Series-2.1.3.156\utils;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS\Source;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS\Source\portable\MemMang;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS\Source\include\;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Factory_Controller
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: Factory_Controller.sct
  link misc: --entry Reset_Handler
  group Source
    ./: Factory_Controller.c startup_rvmdk.S rtc.c outlet.c
    D:/ti/TivaWare_C_Series-2.1.3.156/utils/: uartstdio.c ustdlib.c
    D:/ti/TivaWare_C_Series-2.1.3.156/third_party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    D:/ti/TivaWare_C_Series-2.1.3.156/third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    D:/ti/TivaWare_C_Series-2.1.3.156/third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Inc
    D:/ti/TivaWare_C_Series-2.1.3.156/utils/: ustdlib.h uartstdio.h
    ./: FreeRTOSConfig.h rtc.h outlet.h
  group Driver Library
    D:/ti/TivaWare_C_Series-2.1.3.156/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.0
